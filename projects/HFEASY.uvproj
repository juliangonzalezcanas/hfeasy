# Keil uVision project HFEASY.uvproj, settings and files
target LPXX00 (5060750::V5.06 update 6 (build 750)::.\ARM506u6)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: HFEASY
  AfterMake: fromelf.exe --bin --output ./build_lpxx00/HFEASY.bin ./build_lpxx00/HFEASY.axf
  AfterMake: ../tools/gen_upgrade_bin.exe ./build_lpxx00/HFEASY.bin ./build_lpxx00/HFEASY_UPGRADE.bin
  c flags: OneElfS=1 v6Lang=1 v6LangP=1
  c define: __KEIL_MDK__ __LPXX00__
  c misc: --diag_suppress=494  --c99
  c include: ..\sdk\1.52\include
  scatter file: LPBS2W.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr)
  group src
    ../src/: mqttlib.c startup.c app_main.c httpd.c config.c mqttcli.c gpio.c buzzer.c timer.c led.c relay.c dimmer.c i2c.c network.c echobot.c telebot.c telebot-core.c telebot-parser.c
  group libs
    ../sdk/1.52/libs/: LPB100Kernel.lib
